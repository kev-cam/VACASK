** sch_path: demo/cosim/vacask_cosim_hier/ccap.sch
**.subckt ccap IN VCC CTL
*.ipin IN
*.ipin VCC
*.ipin CTL
CB IN TAIL 'C' m=1
x1 CTL TAIL VCC ainv
**.ends
.end
